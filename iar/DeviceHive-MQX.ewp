# IAR project DeviceHive-MQX.ewp, settings and files
configuration Int Flash DDRData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe997
  ICCARM.CCIncludePath2: ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug; ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug\bsp\Generated_Code; ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug\bsp; ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug\psp; ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug\rtcs; ..\externals\MQX_4_1\lib\twrk70f120m.iar\debug\mfs; ..\Source\CommonSource; ..\Source\CommonSource\Tools; ..\Source\Peripherals; ..\Source\DeviceHive; ..\externals\cJSON; ..\externals\SSL\CyaSSL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk70f120m.iar
  OBJCOPY.OOCOutputFile: DeviceHive-MQX.srec
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkIcfFile: LinkerConfigFiles\intflash_ddrdata.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; NDEBUG
  ICCARM.CCIncludePath2: ..\MQX_4_1\lib\twrk70f120m.iar\release; ..\MQX_4_1\lib\twrk70f120m.iar\release\bsp\Generated_Code; ..\MQX_4_1\lib\twrk70f120m.iar\release\bsp; ..\MQX_4_1\lib\twrk70f120m.iar\release\psp; ..\MQX_4_1\lib\twrk70f120m.iar\release\rtcs; ..\MQX_4_1\lib\twrk70f120m.iar\release\mfs; ..\Commonsource\BuchiGUI_variabel; ..\Commonsource\BuchiGUI_variabel\Fonts; ..\Commonsource\BuchiGUI_variabel\Bitmaps; ..\Commonsource\BuchiGUI_variabel\Menu; ..\CommonSource\BuchiGUI_standard; ..\Commonsource; ..\TargetSource; ..\CommonSource\LibQREncode; ..\FreescaleMQX_4.0.2\lib\twrk70f120m.iar\release\psp; ..\TargetSource\COM; ..\SSL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: VacCtrl_I-300.bin
  postbuild: IncludeBootLoaderBin $PROJ_DIR$ VacCtrl_I-300 BootK70_RS485_V1_00
  ILINK.IlinkKeepSymbols: SSLCert
  group externals/cJSON
    ../externals/cJSON/: cJSON.c cJSON.h
  group externals/MQX Libraries
    ../externals/MQX_4_1/lib/twrk70f120m.iar/debug/bsp/: bsp.a
    ../externals/MQX_4_1/lib/twrk70f120m.iar/debug/mfs/: mfs.a
    ../externals/MQX_4_1/lib/twrk70f120m.iar/debug/psp/: psp.a
    ../externals/MQX_4_1/lib/twrk70f120m.iar/debug/rtcs/: rtcs.a
  group externals/SSL Libraries
    ../externals/SSL/CyaSSL/IDE/IAR-EWARM/Projects/CyaSSL-Lib/Debug/Exe/: CyaSSL-Lib.a
  group Source
    ../Source/: Main.c
  group Source/CommonSource
    ../Source/CommonSource/: CommonTypes.h
  group Source/CommonSource/Tools
    ../Source/CommonSource/Tools/: CCriticalSection.cpp CCriticalSection.h CEvent.cpp CEvent.h CFileIO.cpp CFileIO.h CThread.cpp CThread.h Logger.cpp Logger.h Namespace.h NamespaceEND.h OS.cpp OS.h ToolsLib.h
  group Source/DeviceHive
    ../Source/DeviceHive/: Application.cpp Application.h CommandExecutor.cpp CommandExecutor.h Connection.cpp Connection.h ConnectionGuard.cpp ConnectionGuard.h DeviceHiveMain.cpp DeviceHiveMain.h ErrorDH.cpp ErrorDH.h GatewayDH.cpp GatewayDH.h HttpClient.cpp HttpClient.h HttpTask.cpp HttpTask.h Namespace.h NamespaceEND.h NonCopyable.h REST.cpp REST.h RetryableObject.cpp RetryableObject.h
  group Source/Peripherals
    ../Source/Peripherals/: TestPin_think.c TestPin_think.h
