<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\externals\MQX_4_1\mqx\build\iar\bsp_twrk70f120m\bsp_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\externals\SSL\CyaSSL\IDE\IAR-EWARM\Projects\CyaSSL-Lib\CyaSSL-Lib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\iar\DeviceHive-MQX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\externals\MQX_4_1\mfs\build\iar\mfs_twrk70f120m\mfs_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\externals\MQX_4_1\mqx\build\iar\psp_twrk70f120m\psp_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\externals\MQX_4_1\rtcs\build\iar\rtcs_twrk70f120m\rtcs_twrk70f120m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>DeviceHive-MQX Debug</name>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CyaSSL-Lib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DeviceHive-MQX</project>
        <configuration>Int Flash DDRData Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DeviceHive-MQX Release</name>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>CyaSSL-Lib</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>DeviceHive-MQX</project>
        <configuration>Int Flash DDRData Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


